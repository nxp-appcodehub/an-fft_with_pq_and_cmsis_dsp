# Keil uVision project fft_with_pq_and_cmsis_dsp.uvprojx, settings and files
target fft_with_pq_and_cmsis_dsp (6190000::V6.19::ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: powerquad_benchmark_fft.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S36JBD100, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/LPC55S36/utilities/str;../../../../../../devices/LPC55S36/utilities/debug_console_lite;../../../../../../devices/LPC55S36/drivers;../../../../../../devices/LPC55S36;../../../../../../components/uart;../../../../../../components/lists;../../../../../../CMSIS/DSP/Include;../../../../../../CMSIS/DSP/PrivateInclude;../../../../../../CMSIS/Core/Include
  asm define: CPU_LPC55S36JBD100, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S36_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__powerquad__=1" --predefine="-D__stack_size__=0x8000"
  group source
    ../source/: app_cmsisdsp_cfft_f32.c app_cmsisdsp_cfft_q15.c app_cmsisdsp_cfft_q31.c app_cmsisdsp_format_switch.c app_cmsisdsp_rfft_fast_f32.c app_cmsisdsp_rfft_q15.c app_cmsisdsp_rfft_q31.c app_powerquad_cfft_f32.c app_powerquad_cfft_q15.c app_powerquad_cfft_q31.c app_powerquad_format_switch.c app_powerquad_rfft_f32.c app_powerquad_rfft_q15.c app_powerquad_rfft_q31.c hardware_init.c main.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../../devices/LPC55S36/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/LPC55S36/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/LPC55S36/drivers/: fsl_clock.h fsl_clock.c fsl_powerquad_data.h fsl_powerquad_data.c fsl_powerquad.h fsl_powerquad_basic.c fsl_powerquad_math.c fsl_powerquad_matrix.c fsl_powerquad_filter.c fsl_powerquad_transform.c fsl_powerquad_cmsis.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_power.h fsl_power.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group device
    ../../../../../../devices/LPC55S36/: fsl_device_registers.h LPC55S36.h LPC55S36_features.h system_LPC55S36.c system_LPC55S36.h
  group startup
    ../../../../../../devices/LPC55S36/arm/: startup_LPC55S36.S
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS/DSP/Include
    ../../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h arm_common_tables_f16.h arm_const_structs_f16.h arm_helium_utils.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
    ../../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../../../../../CMSIS/DSP/Source/CommonTables/: arm_const_structs.c arm_common_tables.c
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
    ../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
